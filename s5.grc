options:
  parameters:
    author: drsdr
    generate_options: qt_gui
    id: s5
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: lpf
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '7000'
    gain: '1.0'
    samp_rate: samp_rate
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '96000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '16000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '5000'
    low_cutoff_freq: '100'
    samp_rate: samp_rate/6
    type: fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/drsdr/sdrclass/IQSig_96KHz.wav
    nchan: '2'
    repeat: 'True'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '32000'
    decim: '6'
    samp_rate: samp_rate
    taps: lpf
    type: ccc
  states: {}

connections:
- [band_pass_filter_0, '0', audio_sink_0, '0']
- [blocks_complex_to_mag_0, '0', band_pass_filter_0, '0']
- [blocks_float_to_complex_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0, '1']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_complex_to_mag_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
