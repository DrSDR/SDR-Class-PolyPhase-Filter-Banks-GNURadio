options:
  parameters:
    author: drsdr
    generate_options: qt_gui
    id: s6
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: lpf
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '5000'
    gain: '1.0'
    samp_rate: samp_rate
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '96000'
  states: {}
- name: sx
  id: variable_qtgui_chooser
  parameters:
    label: select polyphase channel
    labels: '[]'
    num_opts: '0'
    options: '[0, 1, 2,3,4,5]'
    type: int
    value: '0'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '16000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '5000'
    low_cutoff_freq: '100'
    samp_rate: samp_rate/6
    type: fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: sx
    num_inputs: '6'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/drsdr/sdrclass/IQSig_96KHz.wav
    nchan: '2'
    repeat: 'True'
  states: {}
- name: pfb_channelizer_ccf_0
  id: pfb_channelizer_ccf
  parameters:
    atten: '100'
    ch_map: '[]'
    nchans: '6'
    osr: '1.0'
    taps: lpf
  states: {}

connections:
- [band_pass_filter_0, '0', audio_sink_0, '0']
- [blocks_complex_to_mag_0, '0', band_pass_filter_0, '0']
- [blocks_float_to_complex_0, '0', pfb_channelizer_ccf_0, '0']
- [blocks_selector_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0, '1']
- [pfb_channelizer_ccf_0, '0', blocks_selector_0, '0']
- [pfb_channelizer_ccf_0, '1', blocks_selector_0, '1']
- [pfb_channelizer_ccf_0, '2', blocks_selector_0, '2']
- [pfb_channelizer_ccf_0, '3', blocks_selector_0, '3']
- [pfb_channelizer_ccf_0, '4', blocks_selector_0, '4']
- [pfb_channelizer_ccf_0, '5', blocks_selector_0, '5']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
