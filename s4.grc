options:
  parameters:
    author: drsdr
    generate_options: qt_gui
    id: s3
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '96000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '16000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '37000'
    low_cutoff_freq: '27000'
    samp_rate: samp_rate
    type: fir_filter_ccc
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_1
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '5000'
    low_cutoff_freq: '100'
    samp_rate: samp_rate/6
    type: fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/drsdr/sdrclass/IQSig_96KHz.wav
    nchan: '2'
    repeat: 'True'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '6'
    interp: '1'
    taps: '1'
    type: ccc
  states: {}

connections:
- [band_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [band_pass_filter_1, '0', audio_sink_0, '0']
- [blocks_complex_to_mag_0, '0', band_pass_filter_1, '0']
- [blocks_float_to_complex_0, '0', band_pass_filter_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0, '1']
- [rational_resampler_xxx_0, '0', blocks_complex_to_mag_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
